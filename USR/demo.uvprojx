# Keil uVision project demo.uvprojx, settings and files
target M3 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\USR;..\FWlib\inc;..\CMSIS;..\BSP\bsp;..\BSP\Comm;..\BSP\DebugGPIO;..\BSP\pub;..\BSP\Tick;..\BSP\delay;..\BSP\Key;..\BSP\DebugUart;..\BSP\Digital
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c
  group BSP
    ../BSP/bsp/: bsp.c
    ../BSP/DebugGPIO/: debug_gpio.c
    ../BSP/DebugUart/: debug_uart.c
    ../BSP/pub/: pub.c
    ../BSP/delay/: delay.c
  group TICK
    ../BSP/Tick/: timer.c timer_core.c
  group COMM
    ../BSP/Comm/: comm_rec.c comm_reply.c communication.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
