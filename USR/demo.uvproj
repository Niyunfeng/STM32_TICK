# Keil uVision project demo.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: demo +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\USR;..\FWlib\inc;..\CMSIS;..\BSP\bsp;..\BSP\Comm;..\BSP\DebugGPIO;..\BSP\pub;..\BSP\Tick;..\BSP\delay;..\BSP\Key;..\BSP\DebugUart
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c
  group BSP
    ../BSP/bsp/: bsp.c
    ../BSP/DebugGPIO/: debug_gpio.c
    ../BSP/pub/: pub.c
    ../BSP/delay/: delay.c
    ../BSP/Key/: key.c
    ../BSP/DebugUart/: debug_uart.c
  group TICK
    ../BSP/Tick/: timer.c timer_core.c
  group COMM
    ../BSP/Comm/: comm_rec.c comm_reply.c communication.c
  group FWLIB
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
    ../CMSIS/startup/: startup_stm32f10x_md.s
